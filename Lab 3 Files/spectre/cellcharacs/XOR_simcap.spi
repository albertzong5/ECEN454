;Spice netlist for an inverter and a capacitor
simulator lang=spectre

include "~/ecen454_714/cadence/cellcharacs/model18.spi"
include "~/ecen454_714/cadence/cellcharacs/cell18.spi"

vgnd (gnd 0) vsource dc=0
vvdd (vdd 0) vsource dc=1.8
vvd (XOR_B 0) vsource dc=1.8

acinput (XOR_A 0) vsource dc=0 mag=1

R1 (XOR_A XOR_A1) resistor r=0

X1 (XOR_A1 XOR_B XOR_out vdd gnd) XOR wp=0.9u lp=0.1u wn=0.4u ln=0.2u

Freq ac start=1e+1 stop=1e+9
save R1:currents
