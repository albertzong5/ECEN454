;Spice netlist for NAND and a capacitor
simulator lang=spectre

include "~/ECEN454/Lab1/spectre/model18.spi"
include "~/ECEN454/Lab1/spectre/cell18.spi"

vgnd (gnd 0) vsource dc=0
vvdd (vdd 0) vsource dc=1.8
vvd (NAND_B 0) vsource dc=1.8

vpwl (NAND_A 0) vsource type=pwl wave=[0n 0 1n 0 1.2n 1.8 4n 1.8 4.2n 0]

X1 (NAND_A NAND_B NAND_OUT vdd gnd) NAND wp=0.6u lp=0.2u wn=0.3u ln=0.2u

R1 (NAND_OUT 1) resistor r=1
C1 (1 0) capacitor c=100f

TransientAnalysis tran start=0 stop=10ns step=1ps
save NAND_A NAND_B NAND_OUT
